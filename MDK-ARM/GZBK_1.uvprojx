# Keil uVision project GZBK_1.uvprojx, settings and files
target GZBK_1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GZBK_1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,DEBUG
  c include: ../Core/Inc;                                        ../Drivers/STM32F1xx_HAL_Driver/Inc;                                        ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                                        ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                                        ../Drivers/CMSIS/Include;                                        ..\drv\drv_led;                                        ..\drv\drv_led;                                        ..\drv;                                        ..\drv\drv_led;                                        ../USB_DEVICE/App;                                        ../USB_DEVICE/Target;                                        ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                        ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                                        ..\drv\drv_power_gpio;                                        ..\drv\drv_log;                                        ..\drv\drv_595;                                        ..\drv\drv_access_con;                                        ..\drv\drv_power_vol;                                        ..\drv\drv_adg714;                                        ..\drv\drv_ad9837;                                        ..\drv\drv_power_wave;                                        ..\drv\drv_power_dds;                                        ..\libcommport;                                        ..\drv\drv_cmd;                                        ..\drv\drv_queue
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../drv/drv_led/: drv_led.c
    ../drv/drv_power_gpio/: drv_power_gpio.c
    ../drv/drv_log/: drv_log.c
    ../drv/drv_595/: drv_595.c
    ../drv/drv_access_con/: drv_access_con.c
    ../drv/drv_power_vol/: drv_power_vol.c
    ../drv/drv_adg714/: drv_adg714.c
    ../drv/drv_ad9837/: drv_ad9837.c
    ../drv/drv_power_wave/: drv_power_wave.c
    ../drv/drv_power_dds/: drv_power_dds.c
    ../libcommport/: comm_prot.c
    ../drv/drv_cmd/: drv_cmd.c
    ../drv/drv_queue/: ring_buffer.c
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
